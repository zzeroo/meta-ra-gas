hostname = "xmz-server-${MACHINE}"
