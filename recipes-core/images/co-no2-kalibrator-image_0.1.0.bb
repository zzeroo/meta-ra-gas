include basic-image.bb

IMAGE_INSTALL += " \
  co-no2-kombisensor-mod-kalibrator \
  co-no2-kombisensor-mod-kalibrator-init \
"
