include basic-image.bb

PR = "r0"

IMAGE_INSTALL += " \
  xmz-mod-touch-test-tool \
  xmz-mod-touch-test-tool-init \
"
