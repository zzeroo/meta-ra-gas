include development-image_0.1.0.bb

PR = "r2"

IMAGE_INSTALL += " \
  xmz-mod-touch-test-tool \
  xmz-mod-touch-test-tool-init \
"
