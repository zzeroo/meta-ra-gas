include basic-image.bb

IMAGE_INSTALL += " \
  xmz-mod-touch-server \
"
